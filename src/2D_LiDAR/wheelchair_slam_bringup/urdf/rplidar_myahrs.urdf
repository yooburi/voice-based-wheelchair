Commit message: prototype success

File: src/2D_LiDAR/wheelchair_slam_bringup/urdf/rplidar_myahrs.urdf (robot description, URDF)
Before this commit: robot wheelchair_bot, 3 links, 2 joints
Joints:
- joint base_to_laser: origin xyz=0.17 0.0 0.20 rpy=0 0 0 -> xyz=0.0 0.23 0.95 rpy=0 0 0
